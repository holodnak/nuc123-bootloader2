# Keil uVision project nuc123-bootloader2.uvproj, settings and files
target nuc123-bootloader2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC123LD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: nuc123-bootloader2
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1
  c include: ..\CMSIS;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\obj\nuc123-bootloader2.sct
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../CMSIS/: core_cm0.c system_NUC1xx.c startup_NUC1xx.s
  group User
    ../: Smpl_MassStorage_ISP.c
  group Library
    ../: MassStorage_ISP.c FlashProg.c
