# Keil uVision project nuc123-bootloader2.uvprojx, settings and files
target nuc123-bootloader2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC123LD4AN0 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.5
  cpu: IROM(0x00000000,0x11000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: nuc123-bootloader2-v2 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: ..\CMSIS;..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\obj\nuc123-bootloader2.sct
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../CMSIS/: core_cm0.c system_NUC1xx.c startup_NUC1xx.s
  group User
    ../: Smpl_MassStorage_ISP.c
  group Library
    ../: MassStorage_ISP.c FlashProg.c
software components: CMSIS:CORE 4.3.0
